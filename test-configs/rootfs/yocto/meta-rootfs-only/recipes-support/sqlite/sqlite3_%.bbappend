PACKAGECONFIG:append = " readline"
DEPENDS:append = " readline"

